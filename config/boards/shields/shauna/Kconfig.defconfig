## config/boards/shields/shauna/Kconfig.defconfig
```kconfig
if SHIELD_SHAUNA

config ZMK_KEYBOARD_NAME
    default "Shauna's Keyboard"

endif
```
